# SPDX-License-Identifier: Apache-2.0
# Copyright (c) 2026 Julian Chu

# 站六十一:eshine-os 镜像聚合(终装)——deploy-only:聚合 eshine-rtos
# 部署四件为镜像目录(boot/)+生成终装 run.sh(启动参数=机器定义
# eshine-qemu-a57-type1.conf 单一事实源)+manifest.json(工件账:
# 版本+sha256)。参考实现 meta-eshine 镜像聚合形态的站内白描。

SUMMARY = "eshine-os image: aggregated bootable deployment set"
DESCRIPTION = "Aggregates eshine-rtos deployed artifacts (eshine.elf \
hypervisor, rtos.bin VM0, guest2.bin bare-metal guest, ramfs.cpio) into \
an image directory with a generated run.sh boot entry and manifest.json \
artifact ledger. Boot params come from the machine definition."
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/Apache-2.0;md5=89aea4e17d99a7cacdbeed46a0096b10"

PV = "27.04"

INHIBIT_DEFAULT_DEPS = "1"
DEPENDS = ""
inherit deploy nopackages

# 聚合上游:eshine-rtos do_deploy 先行;其产物经 deploy 类 sstate 镜像
# 进共享 ${DEPLOY_DIR_IMAGE}(deploy.bbclass:inputdirs=WORKDIR/
# deploy-PN,outputdirs=DEPLOY_DIR_IMAGE)——组装读共享面。
do_deploy[depends] += "eshine-rtos:do_deploy"

# 机器面变量缺省兜底(MACHINE 未设时亦可组装;正形=MACHINE=
# eshine-qemu-a57-type1)
ESHINE_QEMU_MACHINE ??= "virt,virtualization=on,gic-version=3"
ESHINE_QEMU_CPU ??= "cortex-a57"
ESHINE_QEMU_MEMORY ??= "512"
ESHINE_QEMU_CPUS ??= "4"
ESHINE_QEMU_KERNEL_ADDR ??= "0x50000000"
ESHINE_QEMU_GUEST2_ADDR ??= "0x51000000"

ARTIFACTS = "eshine.elf rtos.bin guest2.bin eshine-ramfs.cpio"

do_deploy () {
    IMG="${DEPLOYDIR}/eshine-image"
    install -d "$IMG/boot"
    for a in ${ARTIFACTS}; do
        install -m 0644 "${DEPLOY_DIR_IMAGE}/$a" "$IMG/boot/$a"
    done

    # manifest.json:工件账(版本+机器+sha256;数值=记录面非门)
    {
        printf '{\n'
        printf '  "version": "${PV}",\n'
        printf '  "machine": "${MACHINE}",\n'
        printf '  "artifacts": [\n'
        first=1
        for a in ${ARTIFACTS}; do
            h=$(sha256sum "$IMG/boot/$a" | cut -d' ' -f1)
            [ $first -eq 0 ] && printf ',\n'
            first=0
            printf '    {"name": "%s", "sha256": "%s"}' "$a" "$h"
        done
        printf '\n  ]\n}\n'
    } > "$IMG/manifest.json"

    # run.sh:终装入口(启动参数=机器定义;串口 socket 路径可入参)
    cat > "$IMG/run.sh" <<RUNEOF
#!/bin/sh
# eshine-os image boot entry (generated by eshine-image.bb, machine:
# ${MACHINE}). Usage: ./run.sh [serial-socket-path]
set -e
DIR="\$(cd "\$(dirname "\$0")" && pwd)"
SOCK="\${1:-/tmp/eshine-image-boot.sock}"
rm -f "\$SOCK"
exec qemu-system-aarch64 \\
    -M "${ESHINE_QEMU_MACHINE}" \\
    -cpu "${ESHINE_QEMU_CPU}" -m "${ESHINE_QEMU_MEMORY}" -smp "${ESHINE_QEMU_CPUS}" \\
    -display none -monitor none \\
    -kernel "\$DIR/boot/eshine.elf" \\
    -device loader,file="\$DIR/boot/rtos.bin",addr=${ESHINE_QEMU_KERNEL_ADDR},force-raw=on \\
    -device loader,file="\$DIR/boot/guest2.bin",addr=${ESHINE_QEMU_GUEST2_ADDR},force-raw=on \\
    -chardev socket,id=ser0,path="\$SOCK",server=on,wait=on \\
    -serial chardev:ser0
RUNEOF
    chmod 0755 "$IMG/run.sh"
}
addtask deploy after do_compile before do_build

do_compile[noexec] = "1"
